Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2022-02-03T12:26:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 24.0.16800.0000 - Exporter 20.0.0.364 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Feb 03 12:26:05 2022 * Host: NINB1532 * Database: C:\Users\3113thmo\AppData\Local\Temp\bd9f9a06-78cd-4bd4-853b-d4410ad870ba\50dd3e68-dc2a-4334-90e0-bfbd58a55bea\ifc * Database version: 5507 * Database creation date: Thu Feb 03 12:25:55 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Feb 03 12:25:55 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Feb 03 12:25:55 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Active ventilation, Family1:Active ventilation:205364
In: Level 1
Type - Material: Snow, 255_255_255, Default
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Drain_Diameter: 0 mm; Drain2_Diameter: 0 mm; Exhaust_Diameter: 0 mm; Extract_Diameter: 0 mm; Incomming_Diameter: 0 mm; Supply_Diameter: 0 mm; Supply2_Diameter: 0 mm
Type - Identity Data - Description: Active ventilation; Manufacturer: Genvex; Model: Premium preheat 500 - Left; OmniClass Number: 23.75.70.17.37; OmniClass Title: Unit Ventilators; Type Name: Active ventilation; URL: https://www.genvex.com/produkter/ventilation-opvarmning-og-koling/premium-preheat-500
Type - Other - Category: Mechanical Equipment; Family Name: Family1
Type - Pset_BuildingElementProxyCommon - Reference: Active ventilation
Type - Pset_ManufacturerTypeInformation - Manufacturer: Genvex
Type - Pset_ProductRequirements - Category: Mechanical Equipment
Type - Pset_QuantityTakeOff - Reference: Active ventilation
Pset_BuildingElementProxyCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 2.16301 m2; Volume: 0.519576 m3
Identity Data - Mark: 1
Mechanical - System Classification: Supply Air,Return Air,Supply Air,Other Air,Exhaust Air,Other,Power,Communication
Other - Family: Family1: Active ventilation; Family and Type: Family1: Active ventilation; Type: Family1: Active ventilation; Type Id: Family1: Active ventilation
Phasing - Phase Created: New Construction

# IfcDistributionPort (9)
Description: Flow
Name | FlowDirection
2 x Port_205364 | SOURCE
2 x Port_205364 | SOURCEANDSINK
5 x Port_205364 | SINK
